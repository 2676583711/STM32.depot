# Keil uVision project exp1.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: exp1 +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: CORE;.\FWLIB\inc;.\FWLIB\src;.\OBJ;.\USER
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CORE
    ./CORE/: core_cm3.c system_stm32f10x.c
  group FWLIB
    ./FWLIB/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c
  group OBJ
    ./OBJ/: startup_stm32f10x_md.s
  group USER
    ./USER/: main.c stm32f10x_it.c
